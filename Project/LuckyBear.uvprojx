# Keil uVision project LuckyBear.uvprojx, settings and files
target LuckyBear (6230000::V6.23::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LuckyBear
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CMSIS\Include;..\CMSIS\Device\Include;..\STM32F1xx_HAL_Driver\Inc;..\User;..\Drivers\Inc;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable;..\Middlewares\FreeRTOS\userTask;..\Middlewares\LVGL\lvgl;..\Middlewares\LVGL\lvgl_app;..\Middlewares\LVGL\lvgl\porting;..\Middlewares\LVGL\lvgl\src\core;..\Middlewares\LVGL\lvgl\src\display;..\Middlewares\LVGL\lvgl\src\draw;..\Middlewares\LVGL\lvgl\src\drivers;..\Middlewares\LVGL\lvgl\src\font;..\Middlewares\LVGL\lvgl\src\indev;..\Middlewares\LVGL\lvgl\src\layouts;..\Middlewares\LVGL\lvgl\src\layouts\flex;..\Middlewares\LVGL\lvgl\src\layouts\grid;..\Middlewares\LVGL\lvgl\src\libs\barcode;..\Middlewares\LVGL\lvgl\src\libs\bin_decoder;..\Middlewares\LVGL\lvgl\src\libs\bmp;..\Middlewares\LVGL\lvgl\src\libs\ffmpeg;..\Middlewares\LVGL\lvgl\src\libs\freetype;..\Middlewares\LVGL\lvgl\src\libs\fsdrv;..\Middlewares\LVGL\lvgl\src\misc;..\Middlewares\LVGL\lvgl\src\osal;..\Middlewares\LVGL\lvgl\src\others;..\Middlewares\LVGL\lvgl\src\stdlib;..\Middlewares\LVGL\lvgl\src\themes;..\Middlewares\LVGL\lvgl\src\tick;..\Middlewares\LVGL\lvgl\src\widgets;..\Middlewares\ff15\exfuns;..\Middlewares\ff15\source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/Device/arm/: startup_stm32f103xe.s
    ../CMSIS/Device/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_spi.c
  group User
    ../User/: main.c stm32f1xx_it.c freertos_demo.c
  group Drivers
    ../Drivers/Src/: systemclock.c delay.c uart.c button.c lcd.c lcd_ex.c touch.c 24cxx.c iic.c led.c spi.c spisd.c
  group FreeRTOS/CORE
    ../Middlewares/FreeRTOS/kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/PORT
    ../Middlewares/FreeRTOS/portable/: heap_4.c port.c
  group LVGL/App
    ../Middlewares/LVGL/lvgl_app/: lv_mainstart.c demo.c dropdown_menu.c event_handlers.c screen.c
  group LVGL/porting
    ../Middlewares/LVGL/lvgl/: lv_conf.h lv_port_disp.c lv_port_indev.c
  group LVGL/src
    ../Middlewares/LVGL/lvgl/src/: lv_init.c
  group LVGL/src/core
    ../Middlewares/LVGL/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group LVGL/src/display
    ../Middlewares/LVGL/lvgl/src/display/: lv_display.c
  group LVGL/src/draw
    ../Middlewares/LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middlewares/LVGL/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
  group LVGL/src/font
    ../Middlewares/LVGL/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL/src/indev
    ../Middlewares/LVGL/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group LVGL/src/layouts
    ../Middlewares/LVGL/lvgl/src/layouts/: lv_layout.c
    ../Middlewares/LVGL/lvgl/src/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/lvgl/src/layouts/grid/: lv_grid.c
  group LVGL/src/libs
    ../Middlewares/LVGL/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../Middlewares/LVGL/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middlewares/LVGL/lvgl/src/libs/bmp/: lv_bmp.c
    ../Middlewares/LVGL/lvgl/src/libs/freetype/: lv_ftsystem.c
    ../Middlewares/LVGL/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
  group LVGL/src/misc
    ../Middlewares/LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/LVGL/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c lv_cache_lru_rb.c lv_image_cache.c lv_image_header_cache.c
  group LVGL/src/osal
    ../Middlewares/LVGL/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group LVGL/src/others
    ../Middlewares/LVGL/lvgl/src/others/observer/: lv_observer.c
    ../Middlewares/LVGL/lvgl/src/others/gridnav/: lv_gridnav.c
    ../Middlewares/LVGL/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../Middlewares/LVGL/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/LVGL/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../Middlewares/LVGL/lvgl/src/others/imgfont/: lv_imgfont.c
    ../Middlewares/LVGL/lvgl/src/others/monkey/: lv_monkey.c
    ../Middlewares/LVGL/lvgl/src/others/snapshot/: lv_snapshot.c
    ../Middlewares/LVGL/lvgl/src/others/sysmon/: lv_sysmon.c
    ../Middlewares/LVGL/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../Middlewares/LVGL/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../Middlewares/LVGL/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_parser.c lv_xml_style.c lv_xml_utils.c lv_xml_widget.c
    ../Middlewares/LVGL/lvgl/src/others/xml/parsers/: lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_chart_parser.c lv_xml_dropdown_parser.c lv_xml_event_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
  group LVGL/src/stdlib
    ../Middlewares/LVGL/lvgl/src/stdlib/: lv_mem.c
    ../Middlewares/LVGL/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/LVGL/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/LVGL/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/LVGL/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group LVGL/src/themes
    ../Middlewares/LVGL/lvgl/src/themes/: lv_theme.c
    ../Middlewares/LVGL/lvgl/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/LVGL/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL/lvgl/src/themes/default/: lv_theme_default.c
  group LVGL/src/tick
    ../Middlewares/LVGL/lvgl/src/tick/: lv_tick.c
  group LVGL/src/widgets
    ../Middlewares/LVGL/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/LVGL/lvgl/src/widgets/arc/: lv_arc.c
    ../Middlewares/LVGL/lvgl/src/widgets/bar/: lv_bar.c
    ../Middlewares/LVGL/lvgl/src/widgets/button/: lv_button.c
    ../Middlewares/LVGL/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/LVGL/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/LVGL/lvgl/src/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/LVGL/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/LVGL/lvgl/src/widgets/image/: lv_image.c
    ../Middlewares/LVGL/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/LVGL/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/LVGL/lvgl/src/widgets/led/: lv_led.c
    ../Middlewares/LVGL/lvgl/src/widgets/line/: lv_line.c
    ../Middlewares/LVGL/lvgl/src/widgets/list/: lv_list.c
    ../Middlewares/LVGL/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/LVGL/lvgl/src/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/LVGL/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Middlewares/LVGL/lvgl/src/widgets/roller/: lv_roller.c
    ../Middlewares/LVGL/lvgl/src/widgets/scale/: lv_scale.c
    ../Middlewares/LVGL/lvgl/src/widgets/slider/: lv_slider.c
    ../Middlewares/LVGL/lvgl/src/widgets/span/: lv_span.c
    ../Middlewares/LVGL/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/lvgl/src/widgets/switch/: lv_switch.c
    ../Middlewares/LVGL/lvgl/src/widgets/table/: lv_table.c
    ../Middlewares/LVGL/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/LVGL/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/lvgl/src/widgets/win/: lv_win.c
